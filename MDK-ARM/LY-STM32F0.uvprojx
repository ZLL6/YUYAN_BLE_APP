# Keil uVision project LY-STM32F0.uvprojx, settings and files
target LY-STM32F0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LY-STM32F0 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./bin/YUYAN-U_V14.bin  ./Objects/LY-STM32F0.axf
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F072,USE_STDPERIPH_DRIVER
  c include: ..\LIB;..\LIB\inc;..\System\include;..\System\source;..\USR;..\BSP
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x200010c0 size 0x4000
  group ASM
    ../System/source/arm/: startup_stm32f072.s
  group BSP
    ../BSP/: can.c jdq.c tim.c spi.c w25qxx.c BQ769x0.c SimulateI2C.c data.c wkup.c soc.c flash.c rtc.c EventRecord.c WWDG.c Uart.c
  group USR
    ../USR/: main.c pbdata.c stm32f0xx_it.c pbdata.h
    ../BSP/: Uart.h
  group LIB
    ../LIB/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_can.c stm32f0xx_tim.c stm32f0xx_spi.c stm32f0xx_rtc.c stm32f0xx_pwr.c stm32f0xx_flash.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_iwdg.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ../LIB/: stm32f0xx_conf.h
  group System
    ../System/source/: system_stm32f0xx.c
  group Readme
    ../Readme/: 例程功能说明.txt
